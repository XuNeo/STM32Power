# Keil uVision project PowerV7.uvproj, settings and files
target PowerV7 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: PowerV7
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,M_PI=3.14159265358979f
  c misc: --preinclude ..\USR\stm32f0xx_conf.h
  c include: ..\LIB\CMSIS\Device\ST\STM32F0xx\Include;..\LIB\STM32F0xx_StdPeriph_Driver\inc;..\USR;..\USR\APP;..\USR\driver;..\USR\hal
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    ../USR/: main.c stm32f0xx_it.c
  group APP
    ../USR/app/: CBuff.C pp_buff.c
  group DRIVER
    ../USR/driver/: power.c uart.C
  group LIB
    ../LIB/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../LIB/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030.s
    ../LIB/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_wwdg.c stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
